# Keil uVision project motor.uvprojx, settings and files
target STM32 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08002000,0xE000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: motor +hex
  AfterMake: cmd.exe /c D:\A00KBD\FOC\tools\publish_fw.bat D:\A00KBD\FOC\FOC_Code\Objects motor
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,VECT_TAB_OFFSET=0x2000
  c include: .\lib\inc;.\startup;.\Hardware;.\SimpleFOC;.\user;.\user\AutosarSTD;.\user\CDD_FOC;.\user\MatlabDependencyFiles;.\user\SWC_FOC
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0xE000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./startup/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group Lib
    ./lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Hardware
    ./Hardware/: timer.c delay.c usart.c iic.c adc.c
  group SimpleFOC
    ./SimpleFOC/: foc_utils.c FOCMotor.c BLDCMotor.c PID.c lowpass_filter.c MagneticSensor.c CurrentSense.c
  group User
    ./user/: main.c stm32f10x_it.c
  group AutosarDepend
    ./user/MatlabDependencyFiles/: asr_s32.c asr_s32.h div_nde_s32_floor.c div_nde_s32_floor.h div_nzp_usu32.c div_nzp_usu32.h look1_is32lu32n31Du32_binlcse.c look1_is32lu32n31Du32_binlcse.h mul_s32_sat.c mul_s32_sat.h mul_u32_sat.c mul_u32_sat.h mul_usu32_sat.c mul_usu32_sat.h mul_wide_s32.c mul_wide_s32.h mul_wide_su32.c mul_wide_su32.h mul_wide_u32.c mul_wide_u32.h rt_defines.h rtwtypes.h div_nzp_repeat_u32.c div_nzp_repeat_u32.h const_params.c mul_u32_loSR.c mul_u32_loSR.h multiword_types.h
    ./user/AutosarSTD/: Platform_Types.h Rte_FocCtrl.h Std_Types.h
  group SwcCdd
    ./user/SWC_FOC/: FocCtrl.c FocCtrl.h Swc_Foc.c Swc_Foc.h HapticRatchet.c HapticRatchet.h
    ./user/CDD_FOC/: FocDrv.c FocDrv.h
