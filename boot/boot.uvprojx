# Keil uVision project boot.uvprojx, settings and files
target STM32 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x2000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: boot +hex
  AfterMake: cmd.exe /c D:\A00KBD\FOC\tools\publish_fw.bat D:\A00KBD\FOC\boot\Objects boot
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,
  c include: ..\FOC_Code\lib\inc;..\FOC_Code\startup;..\FOC_Code\user;.\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ../FOC_Code/startup/: system_stm32f10x.c startup_stm32f10x_md.s
  group Boot
    ./src/: main.c
    ../FOC_Code/user/: iap_map.h
